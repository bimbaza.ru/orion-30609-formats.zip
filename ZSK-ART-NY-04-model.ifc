Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:51+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcFurnishingElement: Оборудование благоустройства, ZSK-ART-NY-04 Шар «Ёлочка»
In: Площадка
Description: Оборудование благоустройства. Шар «Ёлочка»; Material: Стеклопластик
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-ART-NY-04; ModelReference: Шар «Ёлочка»; ProductionYear: 2026; ArticleNumber: ZSK-ART-NY-04
ORION_Изделие - Артикул: ZSK-ART-NY-04; Артикул прежний: SD-ART-NY-04; Наименование: Шар «Ёлочка»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: Ø 3000 мм; Материал: Стеклопластик; Цена: Стоимость по запросу; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/art-xmas/30609; Код КСИ: CPr>EDFC; Класс КСИ: Арт-объекты; Коды КСР: …
ADSK - ADSK_Наименование: Шар «Ёлочка»; ADSK_Марка: ZSK-ART-NY-04; ADSK_Код изделия: ZSK-ART-NY-04; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Стеклопластик; ADSK_URL страницы изделия: https://зск.рф/catalog/art-xmas/30609
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDFC; ZSK_Артикул_прежний: SD-ART-NY-04
Qto_ORION - Длина: 3000 mm; Ширина: 3000 mm; Высота: 3000 mm
